# Keil uVision project uart_monster.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_monster
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: usb_uid.c usb_panic.c usb_io.c usb_descriptors.c usb_core.c usb_cdc.c system_interrupts.c system_clock.c status_led.c main.c gpio.c device_config.c cdc_shell.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
